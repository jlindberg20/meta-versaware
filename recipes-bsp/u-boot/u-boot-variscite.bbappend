SRCBRANCH = "imx_v2020.04_5.4.24_2.1.0_var02-vw-carrier"
UBOOT_SRC = "git://github.com/nsdrude-varigit/uboot-imx;protocol=https"
SRCREV = "0e6fb0c9b03712ff9294eab15792c3a0ab3fdc7f"
