SRCBRANCH = "5.4-2.1.x-imx_var01-vw-carrier"
SRCREV = "dafd204212f76bf01dd96031baa0f91ea0745ca7"
KERNEL_SRC = "git://github.com/nsdrude-varigit/linux-imx;protocol=https"

# Override to local directory for developmentdd
# KERNEL_SRC = "git:///home/nate/git/varigit/linux/linux-imx;protocol=file"

KERNEL_DEVICETREE_imx8mn-var-som = "freescale/imx8mn-var-som-versaware.dtb"
