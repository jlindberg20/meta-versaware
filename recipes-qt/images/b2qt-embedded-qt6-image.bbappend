IMAGE_INSTALL_append = " \
    operation-kitchen \
"
